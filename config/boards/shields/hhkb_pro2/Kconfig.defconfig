## config/boards/shields/hhkb_pro2/Kconfig.defconfig
```kconfig
if SHIELD_HHKB_PRO2

choice ZMK_HID_REPORT_TYPE
	default ZMK_HID_REPORT_TYPE_NKRO
endchoice

endif # SHIELD_HHKB_PRO2
```
